# Keil uVision project H743_EcatHost.uvprojx, settings and files
target H743_EcatHost (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H743IITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: H743_EcatHost +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32H743xx
  c include: ../Core/Inc;../BSP/Inc;../App/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../Middlewares/SOEM/inc;../Middlewares/SOEM/osal;../Middlewares/SOEM/oshw;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F
  asm include: ../Core/Inc
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32h743xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c eth.c fdcan.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Application/App
    ../App/Src/: app_eth_debug.c app_uart_log.c ECAT.c ECAT_diag.c ECAT_log.c ECAT_pdo_map.c ECAT_pdo_config.c ECAT_runtime.c ECAT_runtime_sdo.c robot_joint.c robot_trajectory.c ECAT_sdo.c
  group Application/CAN
    ../App/Src/: app_can.c
    ../App/Inc/: app_can.h
  group BSP/Network
    ../BSP/Src/: bsp_lan8720.c bsp_eth_raw.c
  group BSP/Timebase
    ../BSP/Src/: bsp_soem_timebase.c
  group BSP/Serial
    ../BSP/Src/: bsp_rs485.c
  group BSP/Can
    ../BSP/Src/: bsp_can.c
    ../BSP/Inc/: bsp_can.h
  group BSP/Input
    ../BSP/Src/: bsp_key.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_eth.c stm32h7xx_hal_eth_ex.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/SOEM/Core
    ../Middlewares/SOEM/src/: ec_base.c ec_coe.c ec_config.c ec_dc.c ec_main.c ec_print.c ec_soe.c
  group Middlewares/SOEM/osal
    ../Middlewares/SOEM/osal/: osal.c
  group Middlewares/SOEM/oshw
    ../Middlewares/SOEM/oshw/: nicdrv.c oshw.c
software components: CMSIS:CORE 4.3.0
